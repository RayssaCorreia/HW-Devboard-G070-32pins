# Repository RayssaCorreia/HW-Devboard-G070-32pins

File README.md:

# Devboard-G070-32pins
Jornada de desenvolvimento  

### Softwares, ferramentas e tecnologias utilizadas para o projeto

- [Git](https://git-scm.com/) - Controlamento de versionamento 
- [Github](https://github.com/) - Compartilhamento do Projeto 
- [Kicad](https://docs.kicad.org/) - Software de desenvolvimento da PCB 
- [STM32 Cube IDE](https://www.st.com/en/development-tools/stm32cubeide.html) - Software de programação
- [Arduino](https://docs.arduino.cc/hardware/uno-rev3/) - Exemplos e talves gravação via a sua IDE
- [Flatcom](http://flatcam.org/manual/installation.html#linux)
- [CNC Router 3018 Pro 200W](https://router66.com.br/produto/cnc-router-3018-pro-200w/) - maquina para prototipagem da placa
### Comparação entre os pinos do Arduino Uno e o micro stm32g070

### Arduino
- Analog pins 

  | Pin | Function    | Type           | Description                 |
  |-----|-------------|----------------|-----------------------------|
  | 1   | NC          | NC             | Not connected               |
  | 2   | IOREF       | IOREF          | Reference for digital logic V - connected to 5V |
  | 3   | Reset       | Reset          | Reset                       |
  | 4   | +3V3        | Power          | +3V3 Power Rail             |
  | 5   | +5V         | Power          | +5V Power Rail              |
  | 6   | GND         | Power          | Ground                      |
  | 7   | GND         | Power          | Ground                      |
  | 8   | VIN         | Power          | Voltage Input               |
  | 9   | A0          | Analog/GPIO    | Analog input 0 / GPIO       |
  | 10  | A1          | Analog/GPIO    | Analog input 1 / GPIO       |
  | 11  | A2          | Analog/GPIO    | Analog input 2 / GPIO       |
  | 12  | A3          | Analog/GPIO    | Analog input 3 / GPIO       |
  | 13  | A4/SDA      | Analog input/I2C | Analog input 4 / I2C Data line |
  | 14  | A5/SCL      | Analog input/I2C | Analog input 5 / I2C Clock line |

- Digital pins 

  | Pin | Function        | Type             | Description                                  |
  |-----|-----------------|------------------|----------------------------------------------|
  | 1   | D0              | Digital/GPIO     | Digital pin 0 / GPIO                         |
  | 2   | D1              | Digital/GPIO     | Digital pin 1 / GPIO                         |
  | 3   | D2              | Digital/GPIO     | Digital pin 2 / GPIO                         |
  | 4   | D3              | Digital/GPIO     | Digital pin 3 / GPIO                         |
  | 5   | D4              | Digital/GPIO     | Digital pin 4 / GPIO                         |
  | 6   | D5              | Digital/GPIO     | Digital pin 5 / GPIO                         |
  | 7   | D6              | Digital/GPIO     | Digital pin 6 / GPIO                         |
  | 8   | D7              | Digital/GPIO     | Digital pin 7 / GPIO                         |
  | 9   | D8              | Digital/GPIO     | Digital pin 8 / GPIO                         |
  | 10  | D9              | Digital/GPIO     | Digital pin 9 / GPIO                         |
  | 11  | SS              | Digital SPI      | Chip Select                                  |
  | 12  | MOSI            | Digital SPI1     | Main Out Secondary In                        |
  | 13  | MISO            | Digital SPI      | Main In Secondary Out                        |
  | 14  | SCK             | Digital SPI      | Serial clock output                          |
  | 15  | GND             | Power            | Ground                                       |
  | 16  | AREF            | Digital          | Analog reference voltage                     |
  | 17  | A4/SD4          | Digital          | Analog input 4 / I2C Data line (duplicated)  |
  | 18  | A5/SD5          | Digital          | Analog input 5 / I2C Clock line (duplicated) |

### [STMG070KBT6](https://www.st.com/resource/en/datasheet/stm32g070rb.pdf)

| Pin Number | Pin Name (function upon reset)       | Alternate Functions                                |
|------------|--------------------------------------|----------------------------------------------------|
| 1          | PB9                                  | IR_OUT, TIM17_CH1, USART3_RX, SPI2_NSS, I2C1_SDA, EVENTOUT |
| 2          | PC14- OSC32_IN (PC14)                | TIM1_BKIN2                                         |
| 3          | PC15- OSC32_OUT (PC15)               | OSC32_EN, OSC_EN, TIM15_BKIN                       |
| 4          | VDD/VDDA                             | -                                                  |
| 5          | VSS/VSSA                             | -                                                  |
| 6          | NRST                                 | -                                                  |
| 7          | PA0                                  | SPI2_SCK, USART2_CTS, USART4_TX                    |
| 8          | PA1                                  | SPI1_SCK/I2S1_CK, USART2_RTS_DE_CK, USART4_RX      |
| 9          | PA2                                  | SPI1_MOSI/I2S1_SD, USART2_TX, TIM15_CH1            |
| 10         | PA3                                  | SPI2_MISO, USART2_RX, TIM15_CH2, EVENTOUT          |
| 11         | PA4                                  | SPI1_NSS/I2S1_WS, SPI2_MOSI, TIM14_CH1, EVENTOUT   |
| 12         | PA5                                  | SPI1_SCK/I2S1_CK, USART3_TX, EVENTOUT              |
| 13         | PA6                                  | SPI1_MISO/I2S1_MCK, TIM3_CH1, TIM1_BKIN, USART3_CTS, TIM16_CH1 |
| 14         | PA7                                  | SPI1_MOSI/I2S1_SD, TIM3_CH2, TIM1_CH1N, TIM14_CH1, TIM17_CH1 |
| 15         | PB0                                  | SPI1_NSS/I2S1_WS, TIM3_CH3, TIM1_CH2N, USART3_RX   |
| 16         | PB1                                  | TIM14_CH1, TIM3_CH4, TIM1_CH3N, USART3_RTS_DE_CK, EVENTOUT |
| 17         | PB2                                  | SPI2_MISO, USART3_TX, EVENTOUT                     |
| 18         | PA8                                  | MCO, SPI2_NSS, TIM1_CH1, EVENTOUT                  |
| 19         | PA9                                  | MCO, USART1_TX, TIM1_CH2, SPI2_MISO, TIM15_BKIN, I2C1_SCL, EVENTOUT |
| 20         | PC6                                  | TIM3_CH1                                           |
| 21         | PA10                                 | SPI2_MOSI, USART1_RX, TIM1_CH3, TIM17_BKIN, I2C1_SDA, EVENTOUT |
| 22         | PA11                                 | SPI1_MISO/I2S1_MCK, USART1_CTS, TIM1_CH4, TIM1_BKIN2, I2C2_SCL |
| 23         | PA12                                 | SPI1_MOSI/I2S1_SD, USART1_RTS_DE_CK, TIM1_ETR, I2S_CKIN, I2C2_SDA |
| 24         | PA13                                 | SWDIO, IR_OUT, EVENTOUT                            |
| 25         | PA14-BOOT0                           | SWCLK, USART2_TX, EVENTOUT                         |
| 26         | PA15                                 | SPI1_NSS/I2S1_WS, USART2_RX, USART4_RTS_DE_CK, USART3_RTS_DE_CK, EVENTOUT |
| 27         | PB3                                  | SPI1_SCK/I2S1_CK, TIM1_CH2, USART1_RTS_DE_CK, EVENTOUT |
| 28         | PB4                                  | SPI1_MISO/I2S1_MCK, TIM3_CH1, USART1_CTS, TIM17_BKIN, EVENTOUT |
| 29         | PB5                                  | SPI1_MOSI/I2S1_SD, TIM3_CH2, TIM16_BKIN, I2C1_SMBA |
| 30         | PB6                                  | USART1_TX, TIM1_CH3, TIM16_CH1N, SPI2_MISO, I2C1_SCL, EVENTOUT |
| 31         | PB7                                  | USART1_RX, SPI2_MOSI, TIM17_CH1N, USART4_CTS, I2C1_SDA, EVENTOUT |
| 32         | PB8                                  | SPI2_SCK, TIM16_CH1, USART3_TX, TIM15_BKIN, I2C1_SCL, EVENTOUT |

# 

<table>
<thead>
  <tr>
    <th colspan="2">Arduino</th>
    <th colspan="2">Stm32G070</th>
  </tr>
  <tr>
    <td>Bit 0</td>
    <td>Bit 1</td>
    <td>Bit 2</td>
    <td>Bit 3</td>
    <td>Bit 4</td>
    <td>Bit 5</td>
    <td>Bit 6</td>
    <td>Bit 7</td>
    <td>Bit 8</td>
    <td>Bit 9</td>
    <td>Bit 10</td>
    <td>Bit 11</td>
    <td>Bit 12</td>
    <td>Bit 13</td>
    <td>Bit 14</td>
    <td>Bit 15</td>
  </tr>
</thead>
<tbody>
  <tr>
    <th colspan="8">ff</th>
    <th colspan="8">01</th>
  </tr>
  <tr>
    <td colspan="9">        Heading GPS</td>
    <td> Acc</td>
    <td> Jammer</td>
    <td> GPS Status</td>
    <td> Power Supply Status</td>
    <td> Critical Battery</td>
    <td> Ignition</td>
    <td> Speed Value</td>
  </tr>
</tbody>
</table>

## KiCad design Devboard-G070-32pins.kicad_pcb

Parts:
H1, H2: fixing hole; V_1mm

Notes on the sheet:
https://stm32world.com/wiki/DIY_STM32_Programmer_(ST-Link/V2-1)#Flash_Unprotected_Bootloader
https://embarcados.com.br/placa-blue-pill-stm32f103c8t6-detalhes-do-esquematico/
https://www.st.com/resource/en/user_manual/um2401-stm32g0-discovery-kit-for-usb-typec-and-power-delivery-stmicroelectronics.pdf
DICAS
- É uma boa pratica não colocar espaço nem acento em nome de qualquer arquivo, assim você fecha brechas para erros. Ex: "Placa projeto com malha GND" -> "ProjetoMalhaGND ou projeto_malha_gnd" - Separe seu projeto em páginas de acordo com suas funçõe ou caracteristicas similares - Se apertar nas pág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

Parts:
J1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J2, J4: Conn_01x07; PinHeader_1x11_P2.54mm_Vertical
J3: Conn_01x01; hole
J5: HW-769; PinHeader_1x05_P2.54mm_Vertical
J7: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical

Connections:
+3V3: J1.1; also elsewhere on the board
D+: J5.3, J7.2
D-: J5.2, J7.1
DI: J5.4, J7.3
GND: J1.5, J5.5; also elsewhere on the board
NRST: J1.4; also elsewhere on the board
PA1: J3.1, J4.11; also elsewhere on the board
PA4: J2.11; also elsewhere on the board
PA5: J2.10; also elsewhere on the board
PA6: J2.9; also elsewhere on the board
PA7: J2.8; also elsewhere on the board
PA8: J2.4; also elsewhere on the board
PA9: J2.3; also elsewhere on the board
PA10: J2.1; also elsewhere on the board
PA15: J4.1; also elsewhere on the board
PB0: J2.7; also elsewhere on the board
PB1: J2.6; also elsewhere on the board
PB2: J2.5; also elsewhere on the board
PB3: J4.2; also elsewhere on the board
PB4: J4.3; also elsewhere on the board
PB5: J4.4; also elsewhere on the board
PB6: J4.5; also elsewhere on the board
PB7: J4.6; also elsewhere on the board
PB8: J4.7; also elsewhere on the board
PB9: J4.8; also elsewhere on the board
PC6: J2.2; also elsewhere on the board
PC14: J4.9; also elsewhere on the board
PC15: J4.10; also elsewhere on the board
SWCLK: J1.2; also elsewhere on the board
SWDIO: J1.3; also elsewhere on the board
VBUS: J5.1; also elsewhere on the board

Notes on the sheet:
alimentação Jumper para CLock
POWER
PROGRAMER
CONNECTORS
EXTENDERS
Concluido

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C2: 100nF; C_Disc_D1mm
C3: 100uF; CP_Radial_1mm
C4: 22pF; CP_Radial_Tantal_1mm
D1: LED; LED_1mm
D2: LED_RGB
J6: NS6312; PinHeader_1x03_P2.54mm_Vertical
Q1: 2N7002H; TO-251-3_Vertical
Q3: BD237; TO-18-3_Window; not fitted
R1, R6, R7: 100; Resistor_THT_Horizontal_1mm
R2: 1k; Resistor_THT_Horizontal_1mm
R3, R4, R5: 1K; Resistor_THT_Horizontal_1mm
R8: 4.7k; Resistor_THT_Horizontal_1mm
SW1, SW3: SW_MEC_5E; SW_PUSH-12mm
U2: STM32G070KBTx; LQFP-32_7x7mm_P0.8mm

Connections:
+3V3: BZ1.1 (+), C3.1, C4.1, J6.3, R2.1, R8.2, U2.4 (VDD); also elsewhere on the board
BTN_Code: C2.2, R8.1, SW3.3 (K), SW3.4 (A), U2.22 (PA11/PA9)
Buzzer: R6.2, U2.23 (PA12/PA10)
GND: C1.1, C2.1, C3.2, C4.2, D1.1 (K), D2.1 (K), J6.2, Q1.2 (S), R1.2, R7.2, SW1.3 (K), SW1.4 (A), U2.5 (VSS); also elsewhere on the board
LED_B: R5.2, U2.7 (PA0)
LED_G: R4.2, U2.9 (PA2)
LED_R: R3.2, U2.10 (PA3)
NRST: C1.2, SW1.1, SW1.2, U2.6 (NRST); also elsewhere on the board
unnamed: BZ1.2 (-), Q1.3 (D)
unnamed: D1.2 (A), R2.2
unnamed: Q1.1 (G), R6.1, R7.1
unnamed: R1.1, SW3.1, SW3.2
PA1: U2.8 (PA1); also elsewhere on the board
PA4: U2.11 (PA4); also elsewhere on the board
PA5: U2.12 (PA5); also elsewhere on the board
PA6: U2.13 (PA6); also elsewhere on the board
PA7: U2.14 (PA7); also elsewhere on the board
PA8: U2.18 (PA8); also elsewhere on the board
PA9: U2.19 (PA9/NC); also elsewhere on the board
PA10: U2.21 (PA10/NC); also elsewhere on the board
PA15: U2.26 (PA15); also elsewhere on the board
PB0: U2.15 (PB0); also elsewhere on the board
PB1: U2.16 (PB1); also elsewhere on the board
PB2: U2.17 (PB2); also elsewhere on the board
PB3: U2.27 (PB3); also elsewhere on the board
PB4: U2.28 (PB4); also elsewhere on the board
PB5: U2.29 (PB5); also elsewhere on the board
PB6: U2.30 (PB6); also elsewhere on the board
PB7: U2.31 (PB7); also elsewhere on the board
PB8: U2.32 (PB8); also elsewhere on the board
PB9: U2.1 (PB9); also elsewhere on the board
PC6: U2.20 (PC6); also elsewhere on the board
PC14: U2.2 (PC14); also elsewhere on the board
PC15: U2.3 (PC15); also elsewhere on the board
SWCLK: U2.25 (PA14); also elsewhere on the board
SWDIO: U2.24 (PA13); also elsewhere on the board
VBUS: J6.1; also elsewhere on the board

Notes on the sheet:
Microcontroller STM32G070K6
decoupling capacitor
- Separe os circuitos em blocos - Sinal de GND, sempre para baixo - Sinal de VCC, Sempre para cima - Tente seguir uma linha de pensamento nos pocicionamentos dos circuitos: tipo dando continuidade
Button - Reset
BUZZER
LED - Status
DICAS
2N7002 or BD237
LED RGB
Button - Code
LDO module

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
Board: 2 copper layers, 88.0 x 46.0 mm, 28 parts (0 on the bottom side), 40 nets.

## KiCad design v1/Devboard-G070-32pins.kicad_pcb

Board: 2 copper layers, 10 parts (0 on the bottom side), 9 nets, no tracks yet.

Parts:
JP1, JP2, JP3, JP5, JP8, JP9: 2_Open; TestPoint_2Pads_Pitch5.08mm_Drill1.3mm
JP10: TestPoint_2Pads_Pitch5.08mm_Drill1.3mm
Q3: 2N7002H; SOT-23
U1: STM32G070KBTx; LQFP-32_7x7mm_P0.8mm
U2: TLV70233_SOT23-5; SOT-23-5

Connections:
+3V3: U1.4 (VDD), U2.5 (OUT)
BTN_Code: JP5.2 (B), U1.16 (PB1)
GND: Q3.2 (S), U1.5 (VSS), U2.2 (GND)
I2C_SCL: JP9.2 (B), U1.32 (PB8)
I2C_SDA: JP8.2 (B), U1.31 (PB7)
LED_B: JP3.2 (B), U1.21 (PA10/NC)
LED_G: JP2.2 (B), U1.19 (PA9/NC)
LED_R: JP1.2 (B), U1.18 (PA8)
USB_VBUS: JP10.1 (A), U2.1 (IN), U2.3 (EN)

## Commit log

2024-08-28 :heavy_plus_sign: added files of projecto kicad
2024-08-28 :construction: removing v1 folder
2024-09-03 schematic update
2024-10-14 update schematic
2024-10-15 add reduced prototype
2024-10-15 new branch
2024-10-15 added footprints
2024-10-16 [test] BOM
2024-10-17 [perf] update in footprints
2024-10-20 [feat] PCB routing
2024-10-20 [bug] added gnd
2024-10-24 Modifying footprint positions
2024-11-01 done - V1
2024-11-01 Delet Devboard-G070-32pins-backups folder
2024-11-02 bugs
2024-11-07 perf: 45° micro
2024-11-08 board v1
2025-03-23 fix: RGB LED symbol
